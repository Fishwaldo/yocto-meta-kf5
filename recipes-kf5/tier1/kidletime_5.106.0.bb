# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kidletime-${PV}.tar.xz"
SRC_URI[sha256sum] = "a4df680c51a1c86daaa989241b30a3c4f6ce34440e7539766cd61376fe4736f5"

