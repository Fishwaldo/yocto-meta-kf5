# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kholidays-${PV}.tar.xz"
SRC_URI[sha256sum] = "0a65fdd94cbdd04a5898a8740c3074e41a4ba6eb01722e36a9ffce2aafea3b5d"

