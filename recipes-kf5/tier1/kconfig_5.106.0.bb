# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kconfig-${PV}.tar.xz"
SRC_URI[sha256sum] = "05294ed7db971e1c7c7ef9b1429513516a96f4951c768fce2d915c067e75502d"

