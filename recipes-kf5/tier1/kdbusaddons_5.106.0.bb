# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kdbusaddons-${PV}.tar.xz"
SRC_URI[sha256sum] = "8183b45899681f7e8181c33aa573fe43fde8535eb4cb586b310038bbb0eacc17"

