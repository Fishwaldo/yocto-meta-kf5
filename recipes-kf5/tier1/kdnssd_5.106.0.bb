# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kdnssd-${PV}.tar.xz"
SRC_URI[sha256sum] = "117617da7700e5865ee044631f9ea818e49adf3e7a924aca96f3dc197a4ce8bb"

