# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kwindowsystem-${PV}.tar.xz"
SRC_URI[sha256sum] = "3371432556d0c884022f7e16578c775d59066419e5ee34ba1bae2e3fbb19480c"

