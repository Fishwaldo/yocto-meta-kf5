# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/breeze-icons-${PV}.tar.xz"
SRC_URI[sha256sum] = "99eef77c1c663d4086d5051c0867ff78164d656b5c52d53360107454c04930a2"

