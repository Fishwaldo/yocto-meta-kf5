# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/extra-cmake-modules-${PV}.tar.xz"
SRC_URI[sha256sum] = "404f58ecac5d37485e51472ff5f88149f460689bec8792ea29bae279e63cb598"

