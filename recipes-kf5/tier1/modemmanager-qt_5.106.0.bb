# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/modemmanager-qt-${PV}.tar.xz"
SRC_URI[sha256sum] = "7b950378f17b511a2d029f2062726ea0991bc662cdd70a22338e4387acefa491"

