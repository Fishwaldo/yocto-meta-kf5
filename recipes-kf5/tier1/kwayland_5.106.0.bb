# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kwayland-${PV}.tar.xz"
SRC_URI[sha256sum] = "3ef78aec459a4ed3d65af3e371757a1ff0b3298a2817ee9211e32bc519865f56"

