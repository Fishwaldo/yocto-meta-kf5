# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/prison-${PV}.tar.xz"
SRC_URI[sha256sum] = "8fb05129ded9bd26e75bf48a06172d8c1823371260e97def07bb642eb0643bdb"

