# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kimageformats-${PV}.tar.xz"
SRC_URI[sha256sum] = "fb3f3e8aeb97fcf35151787a5ccab4938d4d711415cc5be9d61d768c32790e8f"

