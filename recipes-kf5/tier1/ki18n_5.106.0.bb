# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/ki18n-${PV}.tar.xz"
SRC_URI[sha256sum] = "f1281bb3249b9cf99f89a0750a114858d013655000cb6bb24e5dc332c57b9b4c"

