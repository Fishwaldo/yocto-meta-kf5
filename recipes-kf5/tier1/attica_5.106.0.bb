# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/attica-${PV}.tar.xz"
SRC_URI[sha256sum] = "6c0503d23acf2c17bfc844a0d013aee8ea0f88f258a9f02ea0f66d938d58574e"

