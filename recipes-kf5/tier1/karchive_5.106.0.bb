# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/karchive-${PV}.tar.xz"
SRC_URI[sha256sum] = "fc1e5a8e94bb000ba30a5e7ba975126363c97acec98112ab58aaec1069d5a596"

