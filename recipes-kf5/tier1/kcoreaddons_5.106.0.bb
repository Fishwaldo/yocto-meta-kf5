# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kcoreaddons-${PV}.tar.xz"
SRC_URI[sha256sum] = "e80c50d0d9fc402726d92c869b0314dbb8fe8a2163627f695e0897d7c27cc07c"

