# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kguiaddons-${PV}.tar.xz"
SRC_URI[sha256sum] = "292357236c86066ef5e2680bc49537c9565d7f10c66666670e357d57e994b8d5"

