# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/bluez-qt-${PV}.tar.xz"
SRC_URI[sha256sum] = "31eb83f3968e02268747e561f547a6bca4533ae4f4a3972d349b6adf24d17acc"

