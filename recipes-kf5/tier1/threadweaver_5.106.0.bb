# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/threadweaver-${PV}.tar.xz"
SRC_URI[sha256sum] = "78433646a26f2ea6cab82ccf8e177a46089c77306026ef36a25caea20a161ef6"

