# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kquickcharts-${PV}.tar.xz"
SRC_URI[sha256sum] = "a4b1addcbe634aebab2a36b1a40defc488cdae11f11c4176f2d92c8e5f7f84e8"

