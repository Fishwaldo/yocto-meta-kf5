# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kcodecs-${PV}.tar.xz"
SRC_URI[sha256sum] = "f5dd4213e7747516a8785a0c0c3a59aac19bc797eac8c41c66833a7a26365ea3"

