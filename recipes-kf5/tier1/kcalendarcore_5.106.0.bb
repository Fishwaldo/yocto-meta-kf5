# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kcalendarcore-${PV}.tar.xz"
SRC_URI[sha256sum] = "f478dd78bc1c05ebbda6146f96f920fa5ea8ba62c5d8b902693bf1cfc2589605"

