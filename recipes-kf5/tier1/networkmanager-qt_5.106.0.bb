# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/networkmanager-qt-${PV}.tar.xz"
SRC_URI[sha256sum] = "26abdb7987f2cf15d1f1fa487d10c3d5e96caf0ad6a4e3decb87a1fe4d7b9e1d"

