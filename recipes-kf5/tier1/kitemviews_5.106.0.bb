# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kitemviews-${PV}.tar.xz"
SRC_URI[sha256sum] = "a8a28534a935c5b0ec7db29efc7507d520e08debc58268b8ec729810fb5a2fd6"

