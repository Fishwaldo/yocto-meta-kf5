# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/oxygen-icons5-${PV}.tar.xz"
SRC_URI[sha256sum] = "2dcc8113caebf76144a8b186448d9e76baf06388cd8f95a3ae8b1df448c65086"

