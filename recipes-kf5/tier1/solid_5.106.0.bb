# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/solid-${PV}.tar.xz"
SRC_URI[sha256sum] = "471acaaa850f0ef5116b69caab9293bf3f955dc8a2caedb3f59dd2deacd258af"

