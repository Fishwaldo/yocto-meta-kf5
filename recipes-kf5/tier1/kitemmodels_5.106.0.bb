# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kitemmodels-${PV}.tar.xz"
SRC_URI[sha256sum] = "22a78f28d83174921b6e7803c61c53079a645609418370d368d33df2a6fdb214"

