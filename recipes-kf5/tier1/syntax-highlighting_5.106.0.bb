# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/syntax-highlighting-${PV}.tar.xz"
SRC_URI[sha256sum] = "cd80e3a3bb541f8337e9b29deeabd8545959a02ba1ed9384fb7e8dd7819b1c05"

