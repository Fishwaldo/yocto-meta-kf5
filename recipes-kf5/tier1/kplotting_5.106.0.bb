# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kplotting-${PV}.tar.xz"
SRC_URI[sha256sum] = "c7c55ea3dab5d4c6905c27828eea0c34e977454f7ce9b7facba84a0a3463d785"

