# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kwidgetsaddons-${PV}.tar.xz"
SRC_URI[sha256sum] = "b701be7164d1aea3446b3e647dddf6071609355477daaeb8174531416fd118cc"

