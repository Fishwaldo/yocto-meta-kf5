# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/sonnet-${PV}.tar.xz"
SRC_URI[sha256sum] = "cbad419add82f8000943d686594acaa66ce849fc3f7fb57be7f081c60e280efd"

