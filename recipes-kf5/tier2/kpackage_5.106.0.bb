# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kpackage-${PV}.tar.xz"
SRC_URI[sha256sum] = "a225295c66642be9ad6644cfeb02ff939dd220c3bbe6c52e86e4e56465e13f4c"

