# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kpty-${PV}.tar.xz"
SRC_URI[sha256sum] = "8c1a6db28c10a3605a0759b7ebb0363223653dc1ecf7d2f89e8fc4fa662d2ff2"

