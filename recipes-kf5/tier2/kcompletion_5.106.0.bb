# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kcompletion-${PV}.tar.xz"
SRC_URI[sha256sum] = "a526d609e1135e98b23b7ef64f5627c822b20639fd726f417259313ee5d17f1b"

