# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kjobwidgets-${PV}.tar.xz"
SRC_URI[sha256sum] = "53033c7f4d8a858299d78641d5cd98bb593f43fc40ed9af398b0aadc8b8efe71"

