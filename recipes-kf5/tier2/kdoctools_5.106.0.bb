# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kdoctools-${PV}.tar.xz"
SRC_URI[sha256sum] = "c6b249db8ebd909e46011dbd69d900aed72dcc81363b07222d3649128849ec4c"

