# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kcontacts-${PV}.tar.xz"
SRC_URI[sha256sum] = "e5b7f2f65978da0d52db80ed8f727c5ab5fb5cd3551140305e289a350ca71fd4"

