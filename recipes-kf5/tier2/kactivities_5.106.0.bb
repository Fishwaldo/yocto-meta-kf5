# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kactivities-${PV}.tar.xz"
SRC_URI[sha256sum] = "04b0c6791df66677fe02d60854b8e92c2f423a581be21967b0d0ee1887907701"

