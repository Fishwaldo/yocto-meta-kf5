# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/knotifications-${PV}.tar.xz"
SRC_URI[sha256sum] = "cf24db29bee9659c6ccc7bfc644de44e8785ba3f9de6a1b29ad0d1f3a91f8a9a"

