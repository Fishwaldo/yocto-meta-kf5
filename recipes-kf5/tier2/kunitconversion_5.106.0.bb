# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kunitconversion-${PV}.tar.xz"
SRC_URI[sha256sum] = "b2071aea95b3d37e2ecefa3d794e89aceaf75aa03a5c888734903b4709b2be81"

