# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/syndication-${PV}.tar.xz"
SRC_URI[sha256sum] = "d00d3fcb700f73295f6a05aebc6e96b316548cd90241376ff8e1d913e3d5f79f"

