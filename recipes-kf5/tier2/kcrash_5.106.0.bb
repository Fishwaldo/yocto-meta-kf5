# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kcrash-${PV}.tar.xz"
SRC_URI[sha256sum] = "529e26d32d5826fa075020d2396f4658af8c101da0e7393f9d92c084c4f1244b"

