# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kauth-${PV}.tar.xz"
SRC_URI[sha256sum] = "3cae3e41058c423137db09b14cb6bef5687a07b5e9e70d04e344675143aa6503"

