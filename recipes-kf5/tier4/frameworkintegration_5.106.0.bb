# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/frameworkintegration-${PV}.tar.xz"
SRC_URI[sha256sum] = "a7f5da1948ace55b1c0c5690c283e46b62919403c41b04904e489b7c02516141"

