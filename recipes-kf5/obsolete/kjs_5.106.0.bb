# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/portingAids/kjs-${PV}.tar.xz"
SRC_URI[sha256sum] = "82bf295b3ff863e98ffec6756e6449313c39b747917ad200c41b1c729bfd5249"

