# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/portingAids/khtml-${PV}.tar.xz"
SRC_URI[sha256sum] = "14381ec7008fac941a4b37c8cc6a40e5faad961ced6a6aedf53be855bc12b920"

