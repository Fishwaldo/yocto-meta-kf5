# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/portingAids/khtml-${PV}.tar.xz"
SRC_URI[sha256sum] = "2225870e1e77aab9574d8b959e13e13edf18cebed74e6ac67b21e458e94b8d86"

