# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/portingAids/kjsembed-${PV}.tar.xz"
SRC_URI[sha256sum] = "09846926fd1bea728febe61f6e7d2171a9a508f3038cc4265274b8f5386d153e"

