# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/portingAids/kdelibs4support-${PV}.tar.xz"
SRC_URI[sha256sum] = "ce71650a1c379bdb75726c508e60695855c158ce2e8ea44aacb69d787e2a9cab"

