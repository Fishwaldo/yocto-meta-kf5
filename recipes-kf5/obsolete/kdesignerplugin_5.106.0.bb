# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/portingAids/kdesignerplugin-${PV}.tar.xz"
SRC_URI[sha256sum] = "e0b704286ce797686421a0bf717b62d95fb7369587f77a11ca94cd48cbc8a5dc"

