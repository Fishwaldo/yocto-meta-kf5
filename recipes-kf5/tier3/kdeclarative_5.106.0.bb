# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kdeclarative-${PV}.tar.xz"
SRC_URI[sha256sum] = "c53889b1a5351ec0b84b98da2aa722985979ab8693467c11833219ed3a15e439"

