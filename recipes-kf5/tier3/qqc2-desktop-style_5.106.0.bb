# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/qqc2-desktop-style-${PV}.tar.xz"
SRC_URI[sha256sum] = "daaefed5ad4edeb262c23922a2d766854d9d3ff1889176a812e6a09af39e9db1"

