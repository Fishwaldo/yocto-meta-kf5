# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kglobalaccel-${PV}.tar.xz"
SRC_URI[sha256sum] = "757cca928669905e5db0b8841724fd523956aa2d25aa9282c6960005f022b100"

