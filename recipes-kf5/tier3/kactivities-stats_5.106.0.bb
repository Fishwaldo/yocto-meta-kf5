# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kactivities-stats-${PV}.tar.xz"
SRC_URI[sha256sum] = "62cbebcb9f64cca813a9a04a19a9bceca16729dbd88109efd2a98e654467adca"

