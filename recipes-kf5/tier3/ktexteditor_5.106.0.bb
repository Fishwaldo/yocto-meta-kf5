# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/ktexteditor-${PV}.tar.xz"
SRC_URI[sha256sum] = "c38ddc0515d404f7a9e4a72ac35aaafc3ff7ca9a8b61590f23d382e5f5175f86"

