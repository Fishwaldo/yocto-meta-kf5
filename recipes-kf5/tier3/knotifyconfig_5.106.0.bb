# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/knotifyconfig-${PV}.tar.xz"
SRC_URI[sha256sum] = "b5d98a2e3419b313f3736422e179ebb297929ecfb7c036426498fbeedb561780"

