# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/portingAids/kxmlrpcclient-${PV}.tar.xz"
SRC_URI[sha256sum] = "392802a98ffea84586f4bb777450b880686ac7ad345c021125ae651e7b6235ff"

