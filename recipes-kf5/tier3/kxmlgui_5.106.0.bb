# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kxmlgui-${PV}.tar.xz"
SRC_URI[sha256sum] = "44af980c2c6fcb5922c6809c4df32200ba2008cf25c0c48236dad31a947f18aa"

