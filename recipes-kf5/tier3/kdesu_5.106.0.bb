# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kdesu-${PV}.tar.xz"
SRC_URI[sha256sum] = "abe8bd883fb90d37044630f5d38879a30acace69b790de8b716c505d3a2d75ed"

