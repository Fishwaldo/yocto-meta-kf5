# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/knewstuff-${PV}.tar.xz"
SRC_URI[sha256sum] = "9d8d6e565dacf9b9923e0bd3125859ac6dbc8038d7c5ced8b77943d555f97c0a"

