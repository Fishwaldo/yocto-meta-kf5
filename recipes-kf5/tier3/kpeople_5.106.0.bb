# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kpeople-${PV}.tar.xz"
SRC_URI[sha256sum] = "3e0e2046922133640dae2c68b30603bb670b84809b1ce9cd3dd477300f1d7b58"

