# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/ktextwidgets-${PV}.tar.xz"
SRC_URI[sha256sum] = "4fe2fc5eea7f885dbeec967905718cc0e044d8bf2f22528c27eaa42b7b63a8ad"

