# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/krunner-${PV}.tar.xz"
SRC_URI[sha256sum] = "05131abb83f4de690444cfcd62639dd741b96b5e6efd4400738774552b6b000b"

