# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kservice-${PV}.tar.xz"
SRC_URI[sha256sum] = "1485bf79ae61ea04f29f5f484a143224cc14e898d9eec01271e0258ad29c373f"

