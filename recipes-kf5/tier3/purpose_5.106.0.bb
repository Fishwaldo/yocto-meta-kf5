# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/purpose-${PV}.tar.xz"
SRC_URI[sha256sum] = "819f434dc9d15e05c3d9de4f32a7ce8d7284262035909e15f3a2f95e3c0b72da"

