# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kcmutils-${PV}.tar.xz"
SRC_URI[sha256sum] = "d7dac93cabae54d99d1e642c6fa97b59f3e40b771f1e11fff59910a3df6128d8"

