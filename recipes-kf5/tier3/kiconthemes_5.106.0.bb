# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kiconthemes-${PV}.tar.xz"
SRC_URI[sha256sum] = "eb4f59b63f95ac9911d22bb90df5bcc98d12b19775026c0df6b2601eac47a26a"

