# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kconfigwidgets-${PV}.tar.xz"
SRC_URI[sha256sum] = "05ec1550b058051afa7a76ee7e97edba669b9dbf78beef0dc72aca7b5e8f9b76"

