# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kded-${PV}.tar.xz"
SRC_URI[sha256sum] = "3964f3291a3dda5332a16c51cdad2825045f32dc535ea742e18cb44fde6126a8"

