# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/plasma-framework-${PV}.tar.xz"
SRC_URI[sha256sum] = "4cb3e0217e8eb3d52386530afcd9c1ba304ddc9ac6b661de2d7460c90893891c"

