# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kio-${PV}.tar.xz"
SRC_URI[sha256sum] = "ed2f976422169ff92d67c2c434ac894e22a0216d22567acacb62e87c5908ccb6"

