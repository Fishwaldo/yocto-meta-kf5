# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kparts-${PV}.tar.xz"
SRC_URI[sha256sum] = "683045be175d9b590272cb031405ce810051ef6a297428646a3f18ce8956d7a6"

