# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kwallet-${PV}.tar.xz"
SRC_URI[sha256sum] = "1495def290d19ca4c5704c93b64edada35bc6d7e11d5519c44538876425b55d8"

