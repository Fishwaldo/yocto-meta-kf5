# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kdav-${PV}.tar.xz"
SRC_URI[sha256sum] = "173309587f5bc9d590e0ab7896aee7a5382bf73c858231d816231b28377ab4aa"

