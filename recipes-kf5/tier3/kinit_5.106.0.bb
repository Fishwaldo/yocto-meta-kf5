# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kinit-${PV}.tar.xz"
SRC_URI[sha256sum] = "af3f392426e94c2dcce987af1375ca0668787a2531bfd6f2978ccc0ce979d5a5"

