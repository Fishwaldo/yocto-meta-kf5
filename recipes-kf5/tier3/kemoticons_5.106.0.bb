# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kemoticons-${PV}.tar.xz"
SRC_URI[sha256sum] = "bd921c76939b3f3f7e7367e206c224b8948f31d6309179b18fc2f5c146027b4d"

