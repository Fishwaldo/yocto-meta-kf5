# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/kbookmarks-${PV}.tar.xz"
SRC_URI[sha256sum] = "8d3115d42a6ad460d6e37eeac714bd55ecf15616be224144e243f552a9f33628"

