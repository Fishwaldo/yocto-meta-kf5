# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.106/portingAids/kross-${PV}.tar.xz"
SRC_URI[sha256sum] = "5e303d476c5e4585448beb173116f6ead1b3a227575d56a65335272eb9af6b5f"

