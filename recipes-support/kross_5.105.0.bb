# SPDX-FileCopyrightText: none
# SPDX-License-Identifier: CC0-1.0

require ${PN}.inc
SRC_URI = "https://download.kde.org/stable/frameworks/5.105/portingAids/kross-${PV}.tar.xz"
SRC_URI[sha256sum] = "e54b1ec87296d7cf4ecabe82124be33a1704de370545dbc103c47df9434337fa"

